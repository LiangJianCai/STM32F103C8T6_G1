# Keil uVision project stm32f103.uvprojx, settings and files
target STM32F103 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\STLib\core;..\STLib\core\startup;..\STLib\fwlib\inc;..\utils;..\boards\stm32f103c8t6;..\drivers\led;..\user;..\drivers\beep;..\drivers\usart;..\drivers\key;..\drivers\delay;..\module;..\module\OLED;..\application;..\drivers\adc;..\drivers\rtc;..\drivers\pwm;..\module\GPIO_INPUT;..\module\GPIO_OUTPUT;..\module\DHT11;..\module\DS18B20
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ../STLib/core/: core_cm3.c system_stm32f10x.c
    ../STLib/core/startup/: startup_stm32f10x_md.s
  group fwlib
    ../STLib/fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c
  group drivers
    ../drivers/led/: led.c
    ../drivers/beep/: beep.c
    ../drivers/usart/: usart.c
    ../drivers/key/: key.c
    ../drivers/delay/: delay.c
    ../drivers/adc/: adc.c
    ../drivers/rtc/: rtc.c
    ../drivers/pwm/: pwm.c
  group boards
    ../boards/stm32f103c8t6/: board_config.c
  group module
    ../module/: module_config.c
    ../module/OLED/: OLED.c
    ../module/GPIO_INPUT/: gpio_input.c
    ../module/GPIO_OUTPUT/: gpio_output.c
    ../module/DHT11/: dht11.c
    ../module/DS18B20/: ds18b20.c
  group user
    ../user/: main.c stm32f10x_it.c stm32f10x_conf.h
  group application
    ../application/: sensor_app.c lcd_app.c
  group utils
    ../utils/: system_config.h
  group Doc
    ../Doc/: read.txt
